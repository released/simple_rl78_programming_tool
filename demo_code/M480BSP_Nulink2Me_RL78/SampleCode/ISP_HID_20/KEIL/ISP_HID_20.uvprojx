# Keil uVision project ISP_HID_20.uvprojx, settings and files
target ISP_HID_20 (6190000::V6.19::ARMCLANG)
  device: M484SIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x3FFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: NuLink2MeIapBoot +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc
  asm define: ENABLE_SPIM_CACHE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group User
    ../: main.c descriptors.c hid_transfer.c hsusbd_user.c startup_M480_user.s fmc_user.c isp_user.c targetdev.c
  group Library
    ../../../Library/StdDriver/src/: fmc.c crc.c
