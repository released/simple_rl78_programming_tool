# Keil uVision project Template.uvprojx, settings and files
target Release (6220000::V6.22::ARMCLANG)
  device: M484SIDAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IRAM(0x20000000,0x28000) IROM(0x00004000,0x7C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: NuLink2MeRl78Bridge +hex
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  AfterMake: generateChecksum.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: NULINK2ME_RL78_TARGET_APPROVED=1
  c include: ..\shared\include;..\firmware\core\include;..\firmware\m032_bridge;..\firmware\board;..\firmware\storage;..\firmware\target;..\firmware\nulink2me;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: M484_APROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group NuMicro StdDriver
    ../../../Library/StdDriver/src/: retarget.c clk.c gpio.c hsusbd.c fmc.c spim.c sys.c uart.c
  group Shared Contracts
    ../shared/src/: integrity.c plp_frame.c oip_format.c
  group Programmer Core
    ../firmware/core/src/: programmer_core.c
    ../firmware/m032_bridge/: m032_programmer.c
  group Portable Board and Storage
    ../firmware/board/: m032_board_profile.c m032_board_io.c m032_status_led.c
    ../firmware/storage/: m032_package_store.c
  group RL78 Target
    ../firmware/target/: rl78_protocol_b.c
    ../firmware/nulink2me/: nulink2me_target_binding.c
  group Nu-Link2-Me Binding
    ../firmware/nulink2me/: nulink2me_board_profile.c nulink2me_board.c nulink2me_tool0_soft_uart.c nulink2me_indicator.c nulink2me_spim_storage.c nulink2me_image_cache.c nulink2me_offline_recovery.c nulink2me_application.c nulink2me_hsusbd_port.c nulink2me_iap_control.c nulink2me_hid_descriptors.c nulink2me_main.c
