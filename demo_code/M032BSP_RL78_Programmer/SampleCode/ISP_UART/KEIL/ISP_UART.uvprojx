# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (6220000::V6.22::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: ISP_UART +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\ISP_HID;..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series_User.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: system_M031Series_User.c startup_M031Series_User.s
  group User
    ../../ISP_HID/: fmc_user.c isp_user.c targetdev.c
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c uart.c fmc.c crc.c
