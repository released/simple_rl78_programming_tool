# Keil uVision project M032_TEST_BOARD_APP.uvprojx, settings and files
target Release (6220000::V6.22::ARMCLANG)
  device: M032SE3AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x4000-0xFBFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: M032TestBoardBridge +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.raw.bin"
  AfterMake: generateChecksum_test_board.bat
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1
  c define: M032_INTERNAL_STORAGE_BASE=0x0000FC00,M032_INTERNAL_STORAGE_SIZE=0x00010400,M032_FIRMWARE_END_ADDRESS=0x0000FC00
  c include: ..\shared\include;..\firmware\core\include;..\firmware\m032_bridge;..\firmware\m032_app;..\firmware\board;..\firmware\storage;..\firmware\target;..\firmware\m032_test_board;..\..\..\Library\CMSIS\Core\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0xbc00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: M032_APROM_64K_SLOT.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group NuMicro StdDriver
    ../../../Library/StdDriver/src/: retarget.c clk.c fmc.c gpio.c sys.c uart.c
  group Shared
    ../shared/src/: integrity.c plp_frame.c oip_format.c
  group Core and Bridge
    ../firmware/core/src/: programmer_core.c
    ../firmware/m032_bridge/: m032_programmer.c
    ../firmware/m032_app/: m032_application.c
  group Board
    ../firmware/board/: m032_board_profile.c m032_board_io.c m032_status_led.c m032_numaker_m032se_board.c
    ../firmware/m032_test_board/: m032_test_board_profile.c m032_test_tool0_soft_uart.c m032_test_board.c
  group Storage
    ../firmware/storage/: m032_package_store.c m032_numicro_fmc_storage.c
  group Target
    ../firmware/target/: rl78_protocol_b.c m032_rl78_target_binding.c
  group M032 Application
    ../firmware/m032_test_board/: m032_test_uart_port.c m032_test_main.c
    ../firmware/m032_app/: m032_iap_control.c
